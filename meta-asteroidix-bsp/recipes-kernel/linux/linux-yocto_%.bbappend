COMPATIBLE_MACHINE:append = "|emulator-aarch64"
COMPATIBLE_MACHINE:emulator-aarch64 = "emulator-aarch64"
