# Upstream MainScreen.qml copyright header changed (new 2026 contributor line);
# recipe LIC_FILES_CHKSUM in meta-asteroid is stale vs AUTOREV tip.
LIC_FILES_CHKSUM = "file://src/qml/MainScreen.qml;beginline=1;endline=29;md5=dc9980ea8441655e2d7b323a30b7172d"
SRCREV = "466609c34490e1879f4b05c0946e3038507796fa"
