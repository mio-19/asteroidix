COMPATIBLE_MACHINE:append = "|eos|solios|seluna"
COMPATIBLE_MACHINE:append:aurora = "|eos|solios|seluna"
COMPATIBLE_MACHINE:eos = "eos"
COMPATIBLE_MACHINE:solios = "solios"
COMPATIBLE_MACHINE:seluna = "seluna"
