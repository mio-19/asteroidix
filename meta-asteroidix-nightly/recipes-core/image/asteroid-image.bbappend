# Find phone is part of mio's hoki image. Official builds omit this layer.
IMAGE_INSTALL:append:hoki = " asteroid-findphone"
