COMPATIBLE_MACHINE:append = "|eos"
COMPATIBLE_MACHINE:append:aurora = "|eos"
COMPATIBLE_MACHINE:eos = "eos"
