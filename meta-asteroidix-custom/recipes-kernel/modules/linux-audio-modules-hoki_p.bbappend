# Disable parallel make to prevent race conditions from concurrent descent into dsp/codecs/
PARALLEL_MAKE = ""
PARALLEL_MAKEINST = ""
